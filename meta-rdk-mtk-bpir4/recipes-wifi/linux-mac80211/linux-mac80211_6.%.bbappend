FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://1000-get-station-increase-buffer-size.patch "
